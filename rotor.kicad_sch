File: rotor.kicad_sch (KiCad schematic)
At the start: 26 parts

Commit message: add readme
Other:
- note added: "Program matrix"
- moved on the sheet: R
